# Keil uVision project mesh-light.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: mesh-light +hex
  AfterMake: fromelf.exe --bin -o mesh-light.bin ./output/mesh-light.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,OTA_ENABLE=1,FLASH_ENABLE=1,HCI_ACL_PAYLOAD_SIZE=120,BOARD_V2
  c misc: --gnu
  c include: .\src;..\..\project_common;..\..\..\bundles\typical\inc;..\..\..\bundles\typical\inc\os;..\..\..\bundles\typical\inc\os\portable\RVDS\ARM_CM3;..\..\..\src\BSP;..\..\..\src\FWlib;..\..\..\src\StartUP;..\..\..\src\Tools;..\..\..\src\Mesh
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x3c000
  memory RVCT9: RAM 0x20007a00 size 0xa000
  group APP
    ./src/: main.c profile.c light_model.c RGB_drv.c mesh_flash_oper.c uart_console.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../../bundles/mesh/ING9188xx/: symdefs.m
  group BSP
    ../../../src/BSP/: eflash.c
  group FWlib
    ../../../src/FWlib/: peripheral_gpio.c peripheral_pinctrl.c peripheral_pwm.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
  group Tools
    ../../../src/Tools/: ota_service.c att_db_util.c ad_parser.c
  group Mesh
    ../Mesh/: mesh_srv.c device_composition.c state_binding.c transition.c
  group lib
    ../../../meshlib/: Mesh.lib
  group project_common
    ../../project_common/: bt_cmd_data_uart_io_adp.c bt_cmd_parse.c
software components: CMSIS:CORE 4.3.0
