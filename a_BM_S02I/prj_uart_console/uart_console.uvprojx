# Keil uVision project uart_console.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: uart_console +hex
  AfterMake: fromelf.exe --bin -o uart_console.bin ./output/uart_console.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUGg
  c misc: --gnu
  c include: ../../../bundles/typical/inc;../../../bundles/typical/inc/os;../../../bundles/typical/inc/os/portable/RVDS/ARM_CM3;../../../src/BSP;../../../src/FWlib;../../../src/StartUP;../../../src/Tools;../../../src
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5e000
  memory RVCT9: RAM 0x20007718 size 0x88e8
  group APP
    ../app/: main.c profile.c sdk.c
  group StartUP
    ../../project_common/: startup_app_ing91800.s
    ../../../bundles/typical/ING9188xx/: symdefs.m
  group BSP
    ../../../src/BSP/: bme280.c iic.c eflash.c
  group FWlib
    ../../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_gpio.c peripheral_pinctrl.c peripheral_pwm.c peripheral_i2c.c peripheral_adc.c peripheral_rtc.c
  group Tools
    ../../../src/Tools/: att_db_util.c
  group bt_module
    ../bt_at_cmd_parse/: bt_at_cmd_parse.c bt_at_cmd_sdk_adp.c bt_bm_module_gatt_callback.c bt_bm_module_gatt_service.c
  group project_common
    ../../project_common/: bt_cmd_data_uart_io_adp.c bt_cmd_parse.c
software components: CMSIS:CORE 4.3.0
