# Keil uVision project bt.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00004000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bt +hex
  AfterMake: fromelf.exe --bin -o image.bin ./Objects/bt.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\free_rtos_transp;..\..\..\src\StartUP;..\..\..\src\FWlib;..\..\..\open_source\FreeRTOS\Source\include;..\..\..\open_source\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\app;..\btstack_transp_ing9188
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xffff
  group start_up
    ../../../src/StartUP/: startup_cm32gpm3.s
  group app
    ../app/: main.c app_main.c
  group chip_lib
    ../../../src/FWlib/: peripheral_uart.c peripheral_gpio.c peripheral_pinctrl.c peripheral_sysctrl.c
  group free_rtos
    ../../../open_source/FreeRTOS/Source/: list.c queue.c stream_buffer.c tasks.c event_groups.c timers.c
    ../../../open_source/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../open_source/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group free_rtos_transp
    ../free_rtos_transp/: free_rtos_transp.c
  group btstack_transp
    ../btstack_transp_ing9188/: btstack_transp.c
software components: CMSIS:CORE 4.3.0
