# Keil uVision project burn_flash.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00004000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart_console.hex +hex
  AfterMake: fromelf.exe --bin -o image.bin ./Objects/bt.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\free_rtos_transp;..\start_up\ing918;..\..\..\src\FWlib;..\..\..\open_source\FreeRTOS\Source\include;..\..\..\open_source\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\app;..\btstack_transp
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xffff
software components: CMSIS:CORE 4.3.0
